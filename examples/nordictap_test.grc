options:
  parameters:
    generate_options: qt_gui
    id: nordictap_test
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '1000'
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    address: '''\x55\x55\x55\x55\x55'''
    big_packet: '0'
    channel_count: '1'
    channel_index: '0'
    payload: '''\x20\x20\x20\x20\x32\x30\x2E\x30'''
  states: {}

connections:
- [blocks_message_strobe_0, strobe, nordic_nordictap_transmitter_0, trig]
- [nordic_nordictap_transmitter_0, nordictap_out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
