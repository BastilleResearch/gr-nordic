<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>nordictap_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>nordic_nordictap_transmitter</key>
<param><key>id</key><value>nordic_nordictap_transmitter_0</value></param>
<param><key>address</key><value>\x55\x55\x55\x55\x55</value></param>
<param><key>channel_count</key><value>1</value></param>
<param><key>channel_index</key><value>0</value></param>
<param><key>payload</key><value>\x55\x55\x55\x55\x55</value></param>
<param><key>sequence_number</key><value>0</value></param>
</block>
<connection><source_block_id>nordic_nordictap_transmitter_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>nordictap_out</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
