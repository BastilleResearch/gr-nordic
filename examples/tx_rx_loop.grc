options:
  parameters:
    generate_options: qt_gui
    id: tx_rx_loop
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '[0, 120, 2, 5, 8, 0, 0, 2, 231, 231, 231, 231, 231]'
  states: {}
- name: payload
  id: variable
  parameters:
    value: '"22.75"'
  states: {}
- name: pkt_vec
  id: variable
  parameters:
    value: address + [ ord(x) for x in payload ]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_ctrlport_monitor_performance_0
  id: blocks_ctrlport_monitor_performance
  parameters:
    en: 'True'
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector( len(pkt_vec),  pkt_vec)
    period: '2000'
  states: {state: disabled}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '500'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: nordic_nordic_rx_0
  id: nordic_nordic_rx
  parameters:
    address_length: '5'
    address_match: ''
    channel: '120'
    crc_length: '2'
    data_rate: '2'
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
  states: {}
- name: nordic_nordictap_printer_0
  id: nordic_nordictap_printer
  parameters: {}
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    address: '''\xE7\xE7\xE7\xE7\xE7'''
    big_packet: '0'
    channel_count: '120'
    channel_index: '0'
    payload: payload
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, nordic_nordic_tx_0, nordictap_in]
- [blocks_message_strobe_1, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', nordic_nordic_rx_0, '0']
- [nordic_nordic_rx_0, nordictap_out, nordic_nordictap_printer_0, nordictap_in]
- [nordic_nordic_tx_0, '0', blocks_repack_bits_bb_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
