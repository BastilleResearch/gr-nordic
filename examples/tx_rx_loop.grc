<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_rx_loop</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>address</value></param>
<param><key>value</key><value>[0, 85, 2, 5, 8, 0, 0, 2, 85, 85, 85, 85, 85]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>"    20.0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_vec</value></param>
<param><key>value</key><value>address + [ ord(x) for x in payload ]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.init_u8vector( len(pkt_vec),  pkt_vec)</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>nordic_nordic_rx</key>
<param><key>id</key><value>nordic_nordic_rx_0</value></param>
<param><key>address_length</key><value>5</value></param>
<param><key>crc_length</key><value>2</value></param>
<param><key>data_rate</key><value>2</value></param>
<param><key>channel</key><value>85</value></param>
</block>
<block>
<key>nordic_nordic_tx</key>
<param><key>id</key><value>nordic_nordic_tx_0</value></param>
<param><key>channel_count</key><value>1</value></param>
</block>
<block>
<key>nordic_nordictap_printer</key>
<param><key>id</key><value>nordic_nordictap_printer_0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>nordic_nordic_tx_0</sink_block_id><source_key>strobe</source_key><sink_key>nordictap_in</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>nordic_nordic_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nordic_nordic_rx_0</source_block_id><sink_block_id>nordic_nordictap_printer_0</sink_block_id><source_key>nordictap_out</source_key><sink_key>nordictap_in</sink_key></connection>
<connection><source_block_id>nordic_nordic_tx_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
