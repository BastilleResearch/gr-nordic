options:
  parameters:
    generate_options: qt_gui
    id: tx_nrf_python_block
    output_language: python
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2520e6
  states: {}
- name: payload
  id: variable
  parameters:
    value: '"24.25"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (symbol_rate/2)
    gain: '1.0'
    samp_rate: samp_rate
    width: 250e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/herve/nrf_gfsk.dat
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '1000'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: int(samp_rate/symbol_rate)
    sensitivity: 1.5707/(samp_rate/symbol_rate)
  states: {}
- name: foo_burst_tagger_0
  id: foo_burst_tagger
  parameters:
    mult: int(8*samp_rate/symbol_rate)
    tag_name: pmt.intern("packet_len")
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '2000000'
    buffer_size: '0x200'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    address: '''\xE7\xE7\xE7\xE7\xE7'''
    big_packet: '0'
    channel_count: '120'
    channel_index: '0'
    payload: payload
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    ch_map: '[]'
    connections: '1'
    numchans: '1'
    taps: taps
    twox: 'False'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: 1024*2
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: '1024'
    srate: samp_rate
    tr_tag: '"tx_sob"'
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: 2485e6
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '40'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_mod_0, '0', foo_burst_tagger_0, '0']
- [foo_burst_tagger_0, '0', blocks_file_sink_0, '0']
- [foo_burst_tagger_0, '0', pfb_synthesizer_ccf_0, '0']
- [foo_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [nordic_nordic_tx_0, '0', blocks_repack_bits_bb_0, '0']
- [nordic_nordic_tx_0, '0', digital_gfsk_mod_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, blocks_message_debug_0, print_pdu]
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]
- [pfb_synthesizer_ccf_0, '0', iio_pluto_sink_0, '0']
- [pfb_synthesizer_ccf_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
