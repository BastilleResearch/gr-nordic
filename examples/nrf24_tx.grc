options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '[0, 85, 2, 5, 8, 0, 0, 2, 85, 85, 85, 85, 85]'
  states: {}
- name: payload
  id: variable
  parameters:
    value: '"    20.0"'
  states: {}
- name: pkt_vec
  id: variable
  parameters:
    value: address + [ ord(x) for x in payload ]
  states: {}
- name: probe_var
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: int
    value: probe_var
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector( len(pkt_vec),  pkt_vec)
    period: '500'
  states: {state: disabled}
- name: blocks_message_strobe_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("trig")
    period: '2000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
  states: {}
- name: nordic_nordictap_transmitter_0
  id: nordic_nordictap_transmitter
  parameters:
    address: '''\x55\x55\x55\x55\x55'''
    big_packet: '0'
    channel_count: '1'
    channel_index: '0'
    payload: '''\x20\x20\x20\x20\x32\x30\x2E\x30'''
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: byte
  states: {}

connections:
- [blocks_message_strobe_0, strobe, nordic_nordic_tx_0, nordictap_in]
- [blocks_message_strobe_1, strobe, nordic_nordictap_transmitter_0, trig]
- [blocks_throttle_0, '0', probe_signal, '0']
- [nordic_nordic_tx_0, '0', blocks_throttle_0, '0']
- [nordic_nordictap_transmitter_0, nordictap_out, nordic_nordic_tx_0, nordictap_in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
