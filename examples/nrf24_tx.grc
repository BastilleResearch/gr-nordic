<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>address</value></param>
<param><key>value</key><value>[0, 85, 2, 5, 8, 0, 0, 2, 85, 85, 85, 85, 85]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>"    20.0"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pkt_vec</value></param>
<param><key>value</key><value>address + [ ord(x) for x in payload ]</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>probe_var</value></param>
<param><key>block_id</key><value>probe_signal</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>variable_qtgui_entry_0</value></param>
<param><key>value</key><value>probe_var</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.init_u8vector( len(pkt_vec),  pkt_vec)</value></param>
<param><key>period</key><value>500</value></param>
</block>
<block>
<key>nordic_nordic_tx</key>
<param><key>id</key><value>nordic_nordic_tx_0</value></param>
<param><key>channel_count</key><value>1</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_signal</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>nordic_nordic_tx_0</sink_block_id><source_key>strobe</source_key><sink_key>nordictap_in</sink_key></connection>
<connection><source_block_id>nordic_nordic_tx_0</source_block_id><sink_block_id>probe_signal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
