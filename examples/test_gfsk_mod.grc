options:
  parameters:
    generate_options: qt_gui
    id: test_gfsk_mod
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 500e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/herve/gr-nordic/examples/nordic_transmitter.py
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    log: 'True'
    samples_per_symbol: '2'
    sensitivity: '1.0'
    verbose: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-215-g9a698313
