options:
  parameters:
    generate_options: qt_gui
    id: tx_nrf_foo
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: address
  id: variable
  parameters:
    value: '[0, 120, 2, 5, 8, 2, 0, 2, 231, 231, 231, 231, 231]'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 2520e6
  states: {}
- name: payload
  id: variable
  parameters:
    value: '"22.75"'
  states: {}
- name: pkt_vec
  id: variable
  parameters:
    value: address + [ ord(x) for x in payload ]
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: (symbol_rate/2)*1.5
    gain: '1.0'
    samp_rate: samp_rate
    width: 250e3
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/herve/gr-nordic/examples/data_tr.bin
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.init_u8vector( len(pkt_vec),  pkt_vec)
    period: '1000'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.5'
    samples_per_symbol: '2'
    sensitivity: 1.5707/2
  states: {}
- name: foo_burst_tagger_0
  id: foo_burst_tagger
  parameters:
    mult: int(8*samp_rate/symbol_rate)
    tag_name: pmt.intern("packet_len")
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    auto_filter: 'True'
    bandwidth: '2000000'
    buffer_size: '0x200'
    cyclic: 'False'
    frequency: int(freq)
    samplerate: int(samp_rate)
    uri: ip:192.168.2.1
  states: {}
- name: nordic_nordic_tx_0
  id: nordic_nordic_tx
  parameters:
    channel_count: '1'
  states: {}
- name: pfb_synthesizer_ccf_0
  id: pfb_synthesizer_ccf
  parameters:
    bus_conns: '[[0,],]'
    ch_map: '[]'
    connections: '1'
    numchans: '1'
    taps: taps
    twox: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 3e6
    center_freq0: freq
    clock_rate: '0.0'
    dev_args: '""'
    gain0: '75'
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print_pdu]
- [blocks_message_strobe_0, strobe, nordic_nordic_tx_0, nordictap_in]
- [digital_gfsk_mod_0, '0', foo_burst_tagger_0, '0']
- [foo_burst_tagger_0, '0', pfb_synthesizer_ccf_0, '0']
- [nordic_nordic_tx_0, '0', digital_gfsk_mod_0, '0']
- [pfb_synthesizer_ccf_0, '0', blocks_file_sink_0, '0']
- [pfb_synthesizer_ccf_0, '0', iio_pluto_sink_0, '0']
- [pfb_synthesizer_ccf_0, '0', qtgui_freq_sink_x_0, '0']
- [pfb_synthesizer_ccf_0, '0', qtgui_time_sink_x_0, '0']
- [pfb_synthesizer_ccf_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
