options:
  parameters:
    generate_options: qt_gui
    id: nrf24_receiver
    output_language: python
    realtime_scheduling: '1'
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '5e-4'
    gate: 'False'
    ramp: '0'
    threshold: '-35'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1/((3.1415/2)/2)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_2
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/herve/nrf24_rcv_gr.dat
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/herve/nrf24_rcv_gr_bits.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/herve/gr-nordic/examples/nrf_data.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters:
    comment: |-
      Display recovered
      message
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: 2*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '10101010'
    tagname: burst
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: ((3.1415/2)/2)
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '2000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: '2520000000'
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 1e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 250e3
    win: firdes.WIN_HAMMING
  states: {}
- name: nordic_nordic_rx_0
  id: nordic_nordic_rx
  parameters:
    address_length: '5'
    channel: '120'
    crc_length: '2'
    data_rate: '2'
  states: {}
- name: nordic_nordictap_printer_0
  id: nordic_nordictap_printer
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    size: 1024*256*4
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_eob"'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    size: int(1024/4)
    srate: samp_rate/2
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"burst"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: '1024'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"squelch_sob"'
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    bw0: 2e6
    center_freq0: '2520000000'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '85'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_pwr_squelch_xx_0, '0', low_pass_filter_0, '0']
- [analog_pwr_squelch_xx_0, '0', qtgui_time_sink_x_1, '0']
- [analog_quadrature_demod_cf_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_2, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', analog_pwr_squelch_xx_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_binary_slicer_fb_0, '0', nordic_nordic_rx_0, '0']
- [digital_clock_recovery_mm_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_char_to_float_0_2, '0']
- [digital_gfsk_demod_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [digital_gfsk_demod_0, '0', nordic_nordic_rx_0, '0']
- [iio_pluto_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [low_pass_filter_0, '0', digital_gfsk_demod_0, '0']
- [nordic_nordic_rx_0, nordictap_out, blocks_message_debug_0_0, print_pdu]
- [nordic_nordic_rx_0, nordictap_out, nordic_nordictap_printer_0, nordictap_in]
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']

metadata:
  file_format: 1
